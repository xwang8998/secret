# Keil uVision project SMEC98SPfor8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: SMEC98SPfor8051_stc8g +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\SMEC98SP\Header;.\fpga_i2c
  group Source Group 1
    ./: main.c
  group i2c
    ./moni_I2C_A/: MONI_I2C_A.C
